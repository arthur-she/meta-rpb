FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_rpb = " file://001-remove-stderr-string.patch"
